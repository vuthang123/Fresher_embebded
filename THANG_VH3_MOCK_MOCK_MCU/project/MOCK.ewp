# IAR project MOCK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE16Z64xxx4 NXP MKE16Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MKE16Z64VLF4
  ICCARM.CCIncludePath2: ..\CMSIS\Include; ..\MKE16Z4; ..\source\App; ..\source\Driver\Driver_Button; ..\source\Driver\Driver_Flash; ..\source\Driver\Driver_Led; ..\source\Driver\Driver_UART; ..\source\HAL\HAL_CLOCK; ..\source\HAL\HAL_FLASH; ..\source\HAL\HAL_GPIO; ..\source\HAL\HAL_PORT; ..\source\HAL\HAL_UART; ..\source; ..\source\Middleware; ..\source\HAL\HAL_SYSTICK; ..\source\Driver\Drive_SYSTICK
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MOCK.srec
  ILINK.IlinkOutputFile: MOCK.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group source/APP
    ../source/App/: Application.c Application.h
  group source/BOOT
    ../source/App/: BOOT_APP.c BOOT_APP.h
  group source/DRIVER/DRIVER_BUTTON
    ../source/Driver/Driver_Button/: Driver_Button.c Driver_Button.h
  group source/DRIVER/DRIVER_FLASH
    ../source/Driver/Driver_Flash/: Driver_Flash.c Driver_Flash.h
  group source/DRIVER/DRIVER_LED
    ../source/Driver/Driver_Led/: Driver_Led.c Driver_Led.h
  group source/DRIVER/DRIVER_UART
    ../source/Driver/Driver_UART/: Driver_UART.c Driver_UART.h
  group source/HAL/HAL_CLOCK
    ../source/HAL/HAL_CLOCK/: HAL_CLOCK.c HAL_CLOCK.h
  group source/HAL/HAL_FLASH
    ../source/HAL/HAL_FLASH/: HAL_FLASH.c HAL_FLASH.h
  group source/HAL/HAL_GPIO
    ../source/HAL/HAL_GPIO/: HAL_GPIO.c HAL_GPIO.h
  group source/HAL/HAL_PORT
    ../source/HAL/HAL_PORT/: HAL_PORT.c HAL_PORT.h
  group source/HAL/HAL_UART
    ../source/HAL/HAL_UART/: HAL_UART.c HAL_UART.h
  group source/MIDDLEWARE/MIDDLE_QUEUE
    ../source/Middleware/: MIDware_QUEUE.c MIDware_QUEUE.h
  group source/MIDDLEWARE/MIDDLE_SREC
    ../source/Middleware/: MIDware_SREC.c MIDware_SREC.h
  group startup
    ../MKE16Z4/: startup_MKE16Z4.s system_MKE16Z4.c system_MKE16Z4.h
